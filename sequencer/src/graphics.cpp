#include "display.hpp"
#include <cstring>
namespace t12 {
namespace {
static const uint8_t *glyphFor(char c) {
  static const uint8_t space[5] = {0, 0, 0, 0, 0};
  static const uint8_t digits[10][5] = {
      {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00},
      {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4B, 0x31},
      {0x18, 0x14, 0x12, 0x7F, 0x10}, {0x27, 0x45, 0x45, 0x45, 0x39},
      {0x3C, 0x4A, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03},
      {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1E}};
  static const uint8_t letters[26][5] = {
      {0x7E, 0x11, 0x11, 0x11, 0x7E}, {0x7F, 0x49, 0x49, 0x49, 0x36},
      {0x3E, 0x41, 0x41, 0x41, 0x22}, {0x7F, 0x41, 0x41, 0x22, 0x1C},
      {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x09, 0x01},
      {0x3E, 0x41, 0x49, 0x49, 0x7A}, {0x7F, 0x08, 0x08, 0x08, 0x7F},
      {0x00, 0x41, 0x7F, 0x41, 0x00}, {0x20, 0x40, 0x41, 0x3F, 0x01},
      {0x7F, 0x08, 0x14, 0x22, 0x41}, {0x7F, 0x40, 0x40, 0x40, 0x40},
      {0x7F, 0x02, 0x0C, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F},
      {0x3E, 0x41, 0x41, 0x41, 0x3E}, {0x7F, 0x09, 0x09, 0x09, 0x06},
      {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46},
      {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7F, 0x01, 0x01},
      {0x3F, 0x40, 0x40, 0x40, 0x3F}, {0x1F, 0x20, 0x40, 0x20, 0x1F},
      {0x3F, 0x40, 0x38, 0x40, 0x3F}, {0x63, 0x14, 0x08, 0x14, 0x63},
      {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43}};
  static const uint8_t plus[5] = {0x08,0x08,0x3E,0x08,0x08};
  static const uint8_t colon[5] = {0, 0x36, 0x36, 0, 0};
  static const uint8_t equal[5] = {0x14, 0x14, 0x14, 0x14, 0x14};
  static const uint8_t dash[5] = {0x08, 0x08, 0x08, 0x08, 0x08};
  static const uint8_t greater[5] = {0x00, 0x41, 0x22, 0x14, 0x08};
  static const uint8_t dot[5] = {0, 0x60, 0x60, 0, 0};
  static const uint8_t slash[5] = {0x20, 0x10, 0x08, 0x04, 0x02};
  static const uint8_t sharp[5] = {0x14, 0x7F, 0x14, 0x7F, 0x14};

  if (c >= 'a' && c <= 'z')
    c = char(c - 'a' + 'A');
  if (c >= '0' && c <= '9')
    return digits[c - '0'];
  if (c >= 'A' && c <= 'Z')
    return letters[c - 'A'];
  switch (c) {
  case '+':
    return plus;
  case ':':
    return colon;
  case '=':
    return equal;
  case '-':
    return dash;
  case '>':
    return greater;
  case '.':
    return dot;
  case '/':
    return slash;
  case '#':
    return sharp;
  default:
    return space;
  }
}

} // namespace
void Canvas::clear() { std::memset(data, 0, sizeof(data)); }
void Canvas::pixel(int x, int y, bool on) {
  if (x < 0 || x >= 128 || y < 0 || y >= 64)
    return;
  auto &b = data[x + (y / 8) * 128];
  uint8_t mask = 1u << (y & 7);
  if (on)
    b |= mask;
  else
    b &= uint8_t(~mask);
}
void Canvas::text(int x, int y, const char *s) {
  while (*s) {
    const auto *g = glyphFor(*s++);
    for (int c = 0; c < 5; ++c)
      for (int r = 0; r < 7; ++r)
        if (g[c] & (1u << r))
          pixel(x + c, y + r);
    x += 6;
  }
}
void Canvas::box(int x, int y, int w, int h, bool fill, bool on) {
  for (int j = 0; j < h; ++j)
    for (int i = 0; i < w; ++i)
      if (fill || !i || !j || i == w - 1 || j == h - 1)
        pixel(x + i, y + j, on);
}

} // namespace t12
